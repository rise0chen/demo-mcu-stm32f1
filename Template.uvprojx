# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,DEBUG
  c misc: --cpp11
  c include: .\src;.\lib;.\lib\system;.\lib\Common;.\lib\hardware;.\lib\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.cpp bsp.cpp config.cpp function.cpp fiipTask.cpp fiipVars.cpp myit.cpp
    ./: README.md
  group fiip
    ./lib/fiip-base/: fiip.c fiipListener.c fiipRetransmit.c
    ./lib/fiip-base/link/: link.c route.c
    ./lib/fiip-base/frame/: bufRecver.c crc.c format.c
    ./lib/fiip-link/: linkUsart.cpp
    ./lib/fiip-cloud/: fiipCloud.c fiipCloudVar.c fiipCloudListeners.c
  group riselib
    ./lib/riselib/: task.c flagHandle.c hexChar.c linkedList.c memory.c mempool.c varArray.c
  group Common
    ./lib/Common/: delay.cpp bufRcv.cpp protocol.cpp escape.cpp transCode.cpp font.cpp des.c
  group hardware
    ./lib/hardware/: DHT.cpp DS18B20.cpp EEPROM.cpp Mpu6050.cpp InfraRed.cpp RFID.cpp Ultrasonic.cpp FontRom.cpp
  group system
    ./lib/system/: sys.cpp it.cpp rcc.cpp nvic.cpp gpio.cpp map.cpp exti.cpp dma.cpp adc.cpp dac.cpp pwr.cpp flash.cpp systick.cpp tim.cpp i2c.cpp spi.cpp usart.cpp can.cpp wdg.cpp rtc.cpp crc.cpp stdRewrite.c
  group core
    ./lib/CMSIS/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
    ./lib/CMSIS/: core_cm3.c system_stm32f10x.c
